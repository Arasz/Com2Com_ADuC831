# Keil uVision project pro_usart.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC831 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: pro_usart
  c flags: Optimize=9
  group Source Group 1
    ./: ADuC831.h ADuC831_STD.h main.c DAC.h DAC.c ADuC831_UART.h
